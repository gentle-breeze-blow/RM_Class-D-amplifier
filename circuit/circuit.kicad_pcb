# Repository gentle-breeze-blow/RM_Class-D-amplifier

## KiCad design circuit/circuit.kicad_pcb

Parts:
C1, C5, C12, C14, C17, C20, C31, C37, C38: 10uf; C_0603_1608Metric
C2, C4, C6, C8, C9, C10, C11, C16, C18, C21, C26, C27, C28, C30, C32, C34, C36: 0.1uf; C_0603_1608Metric
C3: 220uf; CP_Radial_D6.3mm_P2.50mm
C7, C13: 18pf; C_0603_1608Metric
C15: 1uf; C_0603_1608Metric
C19: 4.7nf; C_0603_1608Metric
C23, C35: 0.1uf; C_0805_2012Metric
C24: 0.47uf; C_0603_1608Metric
C25: 1uf; C_Axial_L12.0mm_D6.5mm_P20.00mm_Horizontal
C29: 0.01uf; C_0603_1608Metric
D1: LED; LED_0603_1608Metric
D2, D5: 1N5819WS; D_SOD-323_HandSoldering
D3: B340A; D_SMA
D4: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D6, D7, D8, D9: 1N4148W; D_SOD-123
ENA1: EN; TestPoint_Pad_D1.0mm
FB2: 600Ω@100MHz; R_0603_1608Metric
H1, H2, H3, H5: MountingHole; MountingHole_2.2mm_M2_ISO7380_Pad
J1: Barrel_Jack_Switch; BarrelJack_Horizontal
J2: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
J4: AudioJack3_SwitchTR; Jack_3.5mm_Lumberg_1503_02_Horizontal
J5: Conn_01x05; PinHeader_1x05_P2.54mm_Vertical
L1: 15uh; L_Changjiang_FXL0630
L2, L3: 22uh; L_Changjiang_FXL0630
LS1: 8R; TerminalBlock_MaiXu_MX126-5.0-02P_1x02_P5.00mm
Q1, Q2, Q3, Q4: IRLR7843; TO-252-2
R1: 2K; R_0603_1608Metric
R2, R14, R17: 0R; R_0603_1608Metric
R3, R11: 1k; R_0603_1608Metric
R4, R5, R6, R7, R8, R16, R28, R29, R31, R32, R33: 10k; R_0603_1608Metric
R9: 1R; R_0603_1608Metric
R10, R22: 100R; R_0603_1608Metric
R12, R13, R20, R21: 20R; R_0603_1608Metric
R15, R19: 33R; R_0603_1608Metric
R18, R23, R24, R25: 10K; R_0603_1608Metric
R26: 3.24K; R_0603_1608Metric
R27: 12k; R_0603_1608Metric
R30: 2k; R_0603_1608Metric
SW1: SW_Nidec_CAS-120A1; SW_SPDT_CK_JS102011SAQN
SW2: SW_SPST; SW_Tactile_SPST_NO_Straight_CK_PTS636Sx25SMTRLFS
U1: AMS1117-3.3; SOT-223-3_TabPin2
U2: TPS5430DDA; TI_SO-PowerPAD-8_ThermalVias
U3: TLV9062; SOIC-8_5.3x5.3mm_P1.27mm
U4, U6: IR2104; PowerIntegrations_SO-8
U5: STM32G431CBTx; LQFP-48_7x7mm_P0.5mm
Y2: Crystal_GND24; Crystal_SMD_EuroQuartz_MT-4Pin_3.2x2.5mm

Connections:
+3V3: C6.1, C8.1, C9.1, C10.1, C11.1, C14.1, C18.1, J2.1, J5.1, R1.1, R7.1, R14.2, R16.1, R30.1, U1.2 (VO), U3.8 (V+), U5.1 (VBAT), U5.24 (VDD), U5.36 (VDD), U5.48 (VDD)
+5V: C3.1, C4.1, C5.1, L1.2, R25.1, U1.3 (VI)
+12V: C12.1, C20.1, C21.1, C27.1, C30.1, C31.1, C32.1, C36.1, C37.1, C38.1, D2.2 (A), D5.2 (A), Q1.1 (D), Q3.1 (D), SW1.3 (A), U2.7 (VIN), U4.1 (VCC), U6.1 (VCC)
/ADC_in: C19.1, R11.2, U5.8 (PA0)
/KEY: J5.2, U5.43 (PB6)
/NRST: C26.2, R16.2, SW2.1 (A), U5.7 (PG10)
/OSC_N: C13.1, U5.6 (PF1), Y2.3
/OSC_P: C7.1, U5.5 (PF0), Y2.1
/PC13: D4.1 (K), U5.2 (PC13)
/S1: J5.4, U5.41 (PB4)
/S2: J5.3, U5.42 (PB5)
/SD_A: R10.1, U5.32 (PA10)
/SD_B: R22.1, U5.29 (PB15)
/SWCLK: J2.3, U5.38 (PA14)
/SWDIO: J2.2, U5.37 (PA13)
/TIM1_CH1: R19.1, U5.30 (PA8)
/TIM1_CH2: R15.1, U5.31 (PA9)
AGND: C1.2, C2.2, C16.2, C17.2, C18.2, C19.2, C28.2, C34.2, J4.S, R8.2, R17.1, U3.4 (V-), U5.19 (VSSA)
GND: C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C13.2, C14.2, C26.1, D1.1 (K), J2.4, J5.5, R2.2, R17.2, R18.2, SW2.2 (B), U1.1 (GND), U5.23 (VSS), U5.35 (VSS), U5.47 (VSS), Y2.2 (G), Y2.4 (G)
unnamed: C15.2, R4.2, R5.2
unnamed: C24.1, R9.1
unnamed: C24.2, C25.2, L3.2, LS1.2
unnamed: C25.1, L2.2, LS1.1, R9.2
unnamed: C28.1, FB2.2, R14.1
unnamed: D1.2 (A), R1.2
unnamed: C23.1, D2.1 (K), U4.8 (VB)
unnamed: C29.2, D3.1 (K), L1.1, U2.8 (PH)
unnamed: D4.2 (A), R30.2
unnamed: C35.1, D5.1 (K), U6.8 (VB)
unnamed: D6.2 (A), Q1.2 (G), R12.2, R29.2
unnamed: D6.1 (K), R12.1, U4.7 (HO)
unnamed: D7.2 (A), Q2.2 (G), R13.2, R31.2
unnamed: D7.1 (K), R13.1, U4.5 (LO)
unnamed: D8.2 (A), Q3.2 (G), R20.2, R32.2
unnamed: D8.1 (K), R20.1, U6.7 (HO)
unnamed: D9.2 (A), Q4.2 (G), R21.2, R33.2
unnamed: D9.1 (K), R21.1, U6.5 (LO)
unnamed: J4.R, R5.1
unnamed: J4.T, R4.1
unnamed: C23.2, L2.1, Q1.3 (S), Q2.1 (D), R29.1, U4.6 (VS)
unnamed: C35.2, L3.1, Q3.3 (S), Q4.1 (D), R32.1, U6.6 (VS)
unnamed: R11.1, R27.2, U3.7
unnamed: J1.1, SW1.2 (B)
unnamed: C29.1, U2.1 (BOOT)
unnamed: ENA1.1, U2.5 (EN)
unnamed: R25.2, R26.1, U2.4 (VSENSE)
unnamed: C16.1, C17.1, R7.2, R8.1, U3.3 (+)
unnamed: R3.1, U3.1, U3.2 (-)
unnamed: C15.1, R6.2, U3.5 (+)
unnamed: R27.1, R28.2, U3.6 (-)
unnamed: R15.2, U4.2 (IN)
unnamed: R10.2, R23.2, U4.3 (~SD)
unnamed: R18.1, U5.45 (PB8)
unnamed: R19.2, U6.2 (IN)
unnamed: R22.2, R24.2, U6.3 (~SD)
PGND: C3.2, C12.2, C20.2, C21.2, C27.2, C30.2, C31.2, C32.2, C36.2, C37.2, C38.2, D3.2 (A), J1.2, Q2.3 (S), Q4.3 (S), R2.1, R23.1, R24.1, R26.2, R31.1, R33.1, U2.6 (GND), U2.9 (GNDPAD), U4.4 (COM), U6.4 (COM)
VCCA+3V3: C34.1, FB2.1, U5.20 (VREF+), U5.21 (VDDA)
VREF: C1.1, C2.1, R3.2, R6.1, R28.1

Notes on the sheet:
MCU
音频输入
电源管理
下载调试电路
滤波电容
音频输出
编码器
复位电路
MCU指示灯
电源指示灯
地隔离

Board: 2 copper layers, 95.5 x 65.0 mm, 105 parts (1 on the bottom side), 58 nets.

## Code that names these connections

File program/user/src/tim.c:

/* USER CODE BEGIN Header */
/**
  ******************************************************************************
  * @file    tim.c
  * @brief   This file provides code for the configuration
  *          of the TIM instances.
  ******************************************************************************
  * @attention
  *
  * Copyright (c) 2026 STMicroelectronics.
  * All rights reserved.
  *
  * This software is licensed under terms that can be found in the LICENSE file
  * in the root directory of this software component.
  * If no LICENSE file comes with this software, it is provided AS-IS.
  *
  ******************************************************************************
  */
/* USER CODE END Header */
/* Includes ------------------------------------------------------------------*/
#include "tim.h"

/* USER CODE BEGIN 0 */

/* USER CODE END 0 */

TIM_HandleTypeDef htim1;
TIM_HandleTypeDef htim3;

/* TIM1 init function */
void MX_TIM1_Init(void)
{

  /* USER CODE BEGIN TIM1_Init 0 */

  /* USER CODE END TIM1_Init 0 */

  TIM_MasterConfigTypeDef sMasterConfig = {0};
  TIM_OC_InitTypeDef sConfigOC = {0};
  TIM_BreakDeadTimeConfigTypeDef sBreakDeadTimeConfig = {0};

  /* USER CODE BEGIN TIM1_Init 1 */

  /* USER CODE END TIM1_Init 1 */
  htim1.Instance = TIM1;
  htim1.Init.Prescaler = 0;
  htim1.Init.CounterMode = TIM_COUNTERMODE_CENTERALIGNED1;
  htim1.Init.Period = 339;
  htim1.Init.ClockDivision = TIM_CLOCKDIVISION_DIV1;
  htim1.Init.RepetitionCounter = 0;
  htim1.Init.AutoReloadPreload = TIM_AUTORELOAD_PRELOAD_ENABLE;
  if (HAL_TIM_PWM_Init(&htim1) != HAL_OK)
  {
    Error_Handler();
  }
  sMasterConfig.MasterOutputTrigger = TIM_TRGO_RESET;
  sMasterConfig.MasterOutputTrigger2 = TIM_TRGO2_RESET;
  sMasterConfig.MasterSlaveMode = TIM_MASTERSLAVEMODE_DISABLE;
  if (HAL_TIMEx_MasterConfigSynchronization(&htim1, &sMasterConfig) != HAL_OK)
  {
    Error_Handler();
  }
  sConfigOC.OCMode = TIM_OCMODE_PWM1;
  sConfigOC.Pulse = 170;
  sConfigOC.OCPolarity = TIM_OCPOLARITY_HIGH;
  sConfigOC.OCNPolarity = TIM_OCNPOLARITY_HIGH;
  sConfigOC.OCFastMode = TIM_OCFAST_DISABLE;
  sConfigOC.OCIdleState = TIM_OCIDLESTATE_RESET;
  sConfigOC.OCNIdleState = TIM_OCNIDLESTATE_RESET;
  if (HAL_TIM_PWM_ConfigChannel(&htim1, &sConfigOC, TIM_CHANNEL_1) != HAL_OK)
  {
    Error_Handler();
  }
  if (HAL_TIM_PWM_ConfigChannel(&htim1, &sConfigOC, TIM_CHANNEL_2) != HAL_OK)
  {
    Error_Handler();
  }
  sBreakDeadTimeConfig.OffStateRunMode = TIM_OSSR_DISABLE;
  sBreakDeadTimeConfig.OffStateIDLEMode = TIM_OSSI_DISABLE;
  sBreakDeadTimeConfig.LockLevel = TIM_LOCKLEVEL_OFF;
  sBreakDeadTimeConfig.DeadTime = 0;
  sBreakDeadTimeConfig.BreakState = TIM_BREAK_DISABLE;
  sBreakDeadTimeConfig.BreakPolarity = TIM_BREAKPOLARITY_HIGH;
  sBreakDeadTimeConfig.BreakFilter = 0;
  sBreakDeadTimeConfig.BreakAFMode = TIM_BREAK_AFMODE_INPUT;
  sBreakDeadTimeConfig.Break2State = TIM_BREAK2_DISABLE;
  sBreakDeadTimeConfig.Break2Polarity = TIM_BREAK2POLARITY_HIGH;
  sBreakDeadTimeConfig.Break2Filter = 0;
  sBreakDeadTimeConfig.Break2AFMode = TIM_BREAK_AFMODE_INPUT;
  sBreakDeadTimeConfig.AutomaticOutput = TIM_AUTOMATICOUTPUT_DISABLE;
  if (HAL_TIMEx_ConfigBreakDeadTime(&htim1, &sBreakDeadTimeConfig) != HAL_OK)
  {
    Error_Handler();
  }
  /* USER CODE BEGIN TIM1_Init 2 */

  /* USER CODE END TIM1_Init 2 */
  HAL_TIM_MspPostInit(&htim1);

}
/* TIM3 init function */
void MX_TIM3_Init(void)
{

  /* USER CODE BEGIN TIM3_Init 0 */

  /* USER CODE END TIM3_Init 0 */

  TIM_Encoder_InitTypeDef sConfig = {0};
  TIM_MasterConfigTypeDef sMasterConfig = {0};

  /* USER CODE BEGIN TIM3_Init 1 */

  /* USER CODE END TIM3_Init 1 */
  htim3.Instance = TIM3;
  htim3.Init.Prescaler = 0;
  htim3.Init.CounterMode = TIM_COUNTERMODE_UP;
  htim3.Init.Period = 65535;
  htim3.Init.ClockDivision = TIM_CLOCKDIVISION_DIV1;
  htim3.Init.AutoReloadPreload = TIM_AUTORELOAD_PRELOAD_DISABLE;
  sConfig.EncoderMode = TIM_ENCODERMODE_TI12;
  sConfig.IC1Polarity = TIM_ICPOLARITY_RISING;
  sConfig.IC1Selection = TIM_ICSELECTION_DIRECTTI;
  sConfig.IC1Prescaler = TIM_ICPSC_DIV1;
  sConfig.IC1Filter = 0;
  sConfig.IC2Polarity = TIM_ICPOLARITY_RISING;
  sConfig.IC2Selection = TIM_ICSELECTION_DIRECTTI;
  sConfig.IC2Prescaler = TIM_ICPSC_DIV1;
  sConfig.IC2Filter = 0;
  if (HAL_TIM_Encoder_Init(&htim3, &sConfig) != HAL_OK)
  {
    Error_Handler();
  }
  sMasterConfig.MasterOutputTrigger = TIM_TRGO_RESET;
  sMasterConfig.MasterSlaveMode = TIM_MASTERSLAVEMODE_DISABLE;
  if (HAL_TIMEx_MasterConfigSynchronization(&htim3, &sMasterConfig) != HAL_OK)
  {
    Error_Handler();
  }
  /* USER CODE BEGIN TIM3_Init 2 */

  /* USER CODE END TIM3_Init 2 */

}

void HAL_TIM_PWM_MspInit(TIM_HandleTypeDef* tim_pwmHandle)
{

  if(tim_pwmHandle->Instance==TIM1)
  {
  /* USER CODE BEGIN TIM1_MspInit 0 */

  /* USER CODE END TIM1_MspInit 0 */
    /* TIM1 clock enable */
    __HAL_RCC_TIM1_CLK_ENABLE();
  /* USER CODE BEGIN TIM1_MspInit 1 */

  /* USER CODE END TIM1_MspInit 1 */
  }
}

void HAL_TIM_Encoder_MspInit(TIM_HandleTypeDef* tim_encoderHandle)
{

  GPIO_InitTypeDef GPIO_InitStruct = {0};
  if(tim_encoderHandle->Instance==TIM3)
  {
  /* USER CODE BEGIN TIM3_MspInit 0 */

  /* USER CODE END TIM3_MspInit 0 */
    /* TIM3 clock enable */
    __HAL_RCC_TIM3_CLK_ENABLE();

    __HAL_RCC_GPIOB_CLK_ENABLE();
    /**TIM3 GPIO Configuration
    PB4     ------> TIM3_CH1
    PB5     ------> TIM3_CH2
    */
    GPIO_InitStruct.Pin = S1_Pin|S2_Pin;
    GPIO_InitStruct.Mode = GPIO_MODE_AF_PP;
    GPIO_InitStruct.Pull = GPIO_NOPULL;
    GPIO_InitStruct.Speed = GPIO_SPEED_FREQ_LOW;
    GPIO_InitStruct.Alternate = GPIO_AF2_TIM3;
    HAL_GPIO_Init(GPIOB, &GPIO_InitStruct);

  /* USER CODE BEGIN TIM3_MspInit 1 */

  /* USER CODE END TIM3_MspInit 1 */
  }
}
void HAL_TIM_MspPostInit(TIM_HandleTypeDef* timHandle)
{

  GPIO_InitTypeDef GPIO_InitStruct = {0};
  if(timHandle->Instance==TIM1)
  {
  /* USER CODE BEGIN TIM1_MspPostInit 0 */

  /* USER CODE END TIM1_MspPostInit 0 */

    __HAL_RCC_GPIOA_CLK_ENABLE();
    /**TIM1 GPIO Configuration
    PA8     ------> TIM1_CH1
    PA9     ------> TIM1_CH2
    */
    GPIO_InitStruct.Pin = PWMB_Pin|PWMA_Pin;
    GPIO_InitStruct.Mode = GPIO_MODE_AF_PP;
    GPIO_InitStruct.Pull = GPIO_NOPULL;
    GPIO_InitStruct.Speed = GPIO_SPEED_FREQ_LOW;
    GPIO_InitStruct.Alternate = GPIO_AF6_TIM1;
    HAL_GPIO_Init(GPIOA, &GPIO_InitStruct);

  /* USER CODE BEGIN TIM1_MspPostInit 1 */

  /* USER CODE END TIM1_MspPostInit 1 */
  }

}

void HAL_TIM_PWM_MspDeInit(TIM_HandleTypeDef* tim_pwmHandle)
{

  if(tim_pwmHandle->Instance==TIM1)
  {
  /* USER CODE BEGIN TIM1_MspDeInit 0 */

  /* USER CODE END TIM1_MspDeInit 0 */
    /* Peripheral clock disable */
    __HAL_RCC_TIM1_CLK_DISABLE();
  /* USER CODE BEGIN TIM1_MspDeInit 1 */

  /* USER CODE END TIM1_MspDeInit 1 */
  }
}

void HAL_TIM_Encoder_MspDeInit(TIM_HandleTypeDef* tim_encoderHandle)
{

  if(tim_encoderHandle->Instance==TIM3)
  {
  /* USER CODE BEGIN TIM3_MspDeInit 0 */

  /* USER CODE END TIM3_MspDeInit 0 */
    /* Peripheral clock disable */
    __HAL_RCC_TIM3_CLK_DISABLE();

    /**TIM3 GPIO Configuration
    PB4     ------> TIM3_CH1
    PB5     ------> TIM3_CH2
    */
    HAL_GPIO_DeInit(GPIOB, S1_Pin|S2_Pin);

  /* USER CODE BEGIN TIM3_MspDeInit 1 */

  /* USER CODE END TIM3_MspDeInit 1 */
  }
}

/* USER CODE BEGIN 1 */

/* USER CODE END 1 */

File program/user/include/main.h:

/* USER CODE BEGIN Header */
/**
  ******************************************************************************
  * @file           : main.h
  * @brief          : Header for main.c file.
  *                   This file contains the common defines of the application.
  ******************************************************************************
  * @attention
  *
  * Copyright (c) 2026 STMicroelectronics.
  * All rights reserved.
  *
  * This software is licensed under terms that can be found in the LICENSE file
  * in the root directory of this software component.
  * If no LICENSE file comes with this software, it is provided AS-IS.
  *
  ******************************************************************************
  */
/* USER CODE END Header */

/* Define to prevent recursive inclusion -------------------------------------*/
#ifndef __MAIN_H
#define __MAIN_H

#ifdef __cplusplus
extern "C" {
#endif

/* Includes ------------------------------------------------------------------*/
#include "stm32g4xx_hal.h"

/* Private includes ----------------------------------------------------------*/
/* USER CODE BEGIN Includes */

/* USER CODE END Includes */

/* Exported types ------------------------------------------------------------*/
/* USER CODE BEGIN ET */

/* USER CODE END ET */

/* Exported constants --------------------------------------------------------*/
/* USER CODE BEGIN EC */

/* USER CODE END EC */

/* Exported macro ------------------------------------------------------------*/
/* USER CODE BEGIN EM */

/* USER CODE END EM */

/* Exported functions prototypes ---------------------------------------------*/
void Error_Handler(void);

/* USER CODE BEGIN EFP */

/* USER CODE END EFP */

/* Private defines -----------------------------------------------------------*/
#define LED_Pin GPIO_PIN_13
#define LED_GPIO_Port GPIOC
#define ADC_in_Pin GPIO_PIN_0
#define ADC_in_GPIO_Port GPIOA
#define SD_B_Pin GPIO_PIN_15
#define SD_B_GPIO_Port GPIOB
#define PWMB_Pin GPIO_PIN_8
#define PWMB_GPIO_Port GPIOA
#define PWMA_Pin GPIO_PIN_9
#define PWMA_GPIO_Port GPIOA
#define SD_A_Pin GPIO_PIN_10
#define SD_A_GPIO_Port GPIOA
#define S1_Pin GPIO_PIN_4
#define S1_GPIO_Port GPIOB
#define S2_Pin GPIO_PIN_5
#define S2_GPIO_Port GPIOB
#define KEY_Pin GPIO_PIN_6
#define KEY_GPIO_Port GPIOB

/* USER CODE BEGIN Private defines */

/* USER CODE END Private defines */

#ifdef __cplusplus
}
#endif

#endif /* __MAIN_H */

## Commit log

2026-04-10 2
    对programme文件进一步处理，剩余gitignore和reademe需要处理
2026-04-12 3
    更改doc文件下图片命名为英文，对应修改readme文件内的图片链接
